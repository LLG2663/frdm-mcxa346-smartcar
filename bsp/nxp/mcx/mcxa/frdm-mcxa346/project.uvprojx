# Keil uVision project project.uvprojx, settings and files
target rtthread-frdm-mcxa346 (6240000::V6.24::ARMCLANG)
  device: MCXA346VLQ NXP
  pack: NXP.MCXA346_DFP.26.06.00
  cpu: IRAM(0x20000000,0x03c000) IRAM2(0x04000000,0x2000) IROM(0x03000000,0x2000) IROM2(0x00000000,0x0fe000) XRAM(0x04002000,0x2000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: rtthread
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=3
  c define: __CLK_TCK=RT_TICK_PER_SECOND, RT_USING_LIBC, CPU_MCXA346VLQ, __RTTHREAD__, DEBUG, __STDC_LIMIT_MACROS, RT_USING_ARMLIBC
  c misc: --target=arm-arm-none-eabi
  c include: ..\..\..\..\..\components\drivers\clock_time;..\..\..\..\..\libcpu\arm\common;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\drivers\include;.;..\..\..\..\..\components\net\utest;..\libraries\drivers\config;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\drivers\include;packages\nxp-mcx-series-latest\MCXA346\periph2;..\..\..\..\..\components\drivers\smp_call;..\..\..\..\..\components\drivers\spi;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\libc\compilers\common\extension;..\..\..\..\..\components\finsh;..\..\..\..\..\include;..\..\..\..\..\components\drivers\include;board\MCUX_Config\board;..\libraries\drivers;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\libc\compilers\common\extension\fcntl\octal;board;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\libc\posix\io\epoll;..\..\..\..\..\components\drivers\include;..\..\..\..\..\libcpu\arm\cortex-m33;packages\nxp-mcx-series-latest\MCXA346\components\codec;..\..\..\..\..\components\libc\posix\ipc;packages\nxp-mcx-cmsis-latest\Core\Include;packages\nxp-mcx-series-latest\MCXA346\drivers;..\..\..\..\..\components\libc\posix\io\eventfd;applications;..\..\..\..\..\components\libc\compilers\common\include;..\..\..\..\..\components\libc\posix\io\poll;packages\nxp-mcx-series-latest\MCXA346
  asm misc: -x assembler-with-cpp
  memory RVCT4: ROM 0x3000000 size 0x2000
  memory RVCT5: ROM 0x0 size 0xfe000
  memory RVCT6: RAM 0x4002000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x3c000
  memory RVCT10: RAM 0x4000000 size 0x2000
  scatter file: .\board\linker_scripts\MCXA346_flash.scf
  group Applications
    applications/: drv_spi_sample_rw007.c main.c
  group CPU
    ../../../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../../../libcpu/arm/cortex-m33/: context_rvds.S cpuport.c syscall_rvds.S trustzone.c
  group DeviceDrivers
    ../../../../../components/drivers/adc/: adc.c
    ../../../../../components/drivers/clock_time/: clock_boottime.c clock_hrtimer.c clock_time_core.c clock_timer.c
    ../../../../../components/drivers/core/: device.c
    ../../../../../components/drivers/i2c/: dev_i2c_bit_ops.c dev_i2c_core.c dev_i2c_dev.c
    ../../../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../../components/drivers/pin/: dev_pin.c
    ../../../../../components/drivers/rtc/: dev_rtc.c
    ../../../../../components/drivers/serial/: dev_serial.c
    ../../../../../components/drivers/spi/: dev_spi.c dev_spi_core.c
  group Drivers
    board/MCUX_Config/board/: clock_config.c pin_mux.c
    board/: board.c
    ../libraries/drivers/: drv_pin.c drv_timer.c drv_uart.c
  group Finsh
    ../../../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    ../../../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
  group Libraries
    packages/nxp-mcx-series-latest/MCXA346/drivers/: fsl_aoi.c fsl_clock.c fsl_cmc.c fsl_common.c fsl_common_arm.c fsl_crc.c fsl_ctimer.c fsl_edma.c fsl_edma_soc.c fsl_eim.c fsl_eqdc.c fsl_erm.c fsl_flexcan.c fsl_flexcan_edma.c fsl_freqme.c fsl_glikey.c fsl_gpio.c fsl_inputmux.c fsl_lpadc.c fsl_lpcmp.c fsl_lpi2c.c fsl_lpi2c_edma.c fsl_lpspi.c fsl_lpspi_edma.c fsl_lptmr.c fsl_lpuart.c fsl_lpuart_edma.c fsl_ostimer.c fsl_pwm.c fsl_reset.c fsl_spc.c fsl_utick.c fsl_vbat.c fsl_waketimer.c fsl_wuu.c fsl_wwdt.c
    packages/nxp-mcx-series-latest/MCXA346/: startup_MCXA346.c system_MCXA346.c
